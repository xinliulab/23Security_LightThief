options:
  parameters:
    generate_options: qt_gui
    id: tx_cw
    output_language: python
    title: tx_cw
  states: {}

blocks:
- name: bd
  id: variable
  parameters:
    value: '250000'
  states: {}
- name: cwFreq
  id: variable
  parameters:
    value: '108000000'
  states: {}
- name: cwGain
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-90'
    step: '10'
    stop: '90'
    value: '0'
  states: {}
- name: opticalRate
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '100000'
    step: '100000'
    stop: '400000'
    value: '100000'
  states: {}
- name: ratio
  id: variable
  parameters:
    value: '4'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 2.4e6
  states: {}
- name: analog_sig_source_x_0
  id: analog_sig_source_x
  parameters:
    amp: '0.5'
    freq: '0'
    offset: '0'
    phase: '0'
    samp_rate: samp_rate
    type: complex
    waveform: analog.GR_CONST_WAVE
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/rxSig.bin
    type: complex
  states: {}
- name: note_0
  id: note
  parameters:
    note: CW Sender
  states: {}
- name: note_0_0
  id: note
  parameters:
    note: Spectrum Analyzer
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: ratio*opticalRate
    fc: cwFreq+opticalRate
    fftsize: '1024'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: ratio*opticalRate
    fc: cwFreq+opticalRate
    fftsize: '1024'
    grid: 'True'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: TX/RX
    center_freq0: cwFreq
    dev_args: '""'
    gain0: cwGain
    len_tag_name: ''
    norm_gain0: 'False'
    samp_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: RX2
    center_freq0: cwFreq+opticalRate
    dc_offs_enb0: '""'
    dev_args: '""'
    iq_imbal_enb0: '""'
    norm_gain0: 'False'
    rx_agc0: Enabled
    samp_rate: ratio*opticalRate
    sync: none
    type: fc32
  states: {}

connections:
- [analog_sig_source_x_0, '0', uhd_usrp_sink_0, '0']
- [uhd_usrp_source_0, '0', blocks_file_sink_0, '0']
- [uhd_usrp_source_0, '0', qtgui_freq_sink_x_0, '0']
- [uhd_usrp_source_0, '0', qtgui_waterfall_sink_x_0, '0']

metadata:
  file_format: 1
